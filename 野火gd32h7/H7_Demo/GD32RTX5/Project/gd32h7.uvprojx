# Keil uVision project gd32h7.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gd32h7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SIMULATOR_ENV=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\CMSIS\GD\GD32H7xx\Include;..\GD32H7xx_FWLIB\Include;..\User;..\BSP\led;..\BSP\usart;..\BSP\systick;..\RTX5\inc;..\RTX5\config;..\CMSIS\Core\Include;..\CMSIS\Compiler;..\CMSIS\RTOS2\Include;..\CMSIS\GD\GD32H7xx\Include;..\BSP\key;..\BSP\can;..\Drivers\CanOpen\CanFestival-3\include;..\Drivers\CanOpen\CanFestival-3\include\GD32;..\Drivers\CanOpen\CanFestival-3\example;..\CBB\user\basecalfunc;..\Drivers\Can;..\Drivers\Common;..\Drivers
  asm define: SIMULATOR_ENV=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Startup
    ../CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group CMSIS
    ../CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group GD32H7xx_FWLIB
    ../GD32H7xx_FWLIB/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Drivers
    ../Drivers/Can/: drv_can.c
  group CanFestival-3
    ../Drivers/CanOpen/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c symbols.c
  group CanOpen
    ../Drivers/CanOpen/CanFestival-3/example/: LinkCanopenMaster.c ObjectDictionary.c
    ../Drivers/CanOpen/CanFestival-3/drivers/GD32/: canfestival_timer.c
  group BSP
    ../BSP/led/: bsp_gpio_led.c
    ../BSP/usart/: bsp_usart.c
    ../BSP/systick/: systick.c
    ../BSP/key/: bsp_gpio_key.c
    ../BSP/can/: bsp_can_fd.c
  group CBB
    ../CBB/user/basecalfunc/: basecalfunc.c
  group RTX5_Source
    ../RTX5/src/: irq_armv7m.s rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c os_systick.c
  group RTX5_Config
    ../RTX5/config/: RTX_Config.c
  group User
    ../User/: main.c gd32h7xx_it.c RTE_Components.h can_test.c
  group Doc
    ../Doc/: readme.txt
