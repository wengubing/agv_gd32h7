# Keil uVision project Fire_H759IM_TEST.uvprojx, settings and files
target TEST (6190000::V6.19::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_PRINT
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\lwip-2.1.2\src\include;..\lwip-2.1.2\src\include\ipv4;..\lwip-2.1.2\src\include\netif;..\lwip-2.1.2\src\include\lwip;..\lwip-2.1.2\port\GD32H7xx;..\lwip-2.1.2\port\GD32H7xx\Basic;..\;..\Firmware\CMSIS\GD\GD32H7xx\Include;..\Firmware\GD32H7xx_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x24080000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  group Startup
    ../Firmware/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group CMSIS
    ../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Periphal
    ../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group User
    ../User/: main.c gd32h7xx_it.c netconf.c
    ../User/systick/: bsp_systick.c
    ../User/dwt/: bsp_dwt_delay.c
    ../User/debug/: bsp_gpio_debug.c
    ../User/usart/: bsp_usart.c
    ../User/enet/: bsp_enet.c
    ../User/led/: bsp_gpio_led.c
    ../User/sdram/: bsp_exmc_sdram.c
    ../User/ospi/: bsp_ospi.c bsp_ospi_gd25q64.c
    ../User/beep/: bsp_gpio_beep.c
    ../User/adc/: bsp_adc.c
    ../User/key/: bsp_gpio_key.c
    ../User/potentiometer/: bsp_gpio_potentiometer.c
    ../User/rtc/: bsp_rtc.c
    ../User/lcd/: bsp_lcd.c
    ../User/fonts/: fonts.c
    ../User/sdio/: bsp_sdio.c bsp_sdio_sdcard.c bsp_sdio_test.c
    ../User/lan8720a/: bsp_lan8720a.c
  group LWIP
    ../lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.1.2/src/netif/: ethernet.c
    ../lwip-2.1.2/src/apps/lwiperf/: lwiperf.c
    ../lwip-2.1.2/port/GD32H7xx/Basic/: ethernetif.c
  group APP
    ../App/led/: app_led.c
    ../App/flash/: app_flash.c
    ../App/sdram/: app_sdram.c
    ../App/key/: app_key.c
    ../App/potentiometer/: app_potentiometer.c
    ../App/rtc/: app_rtc.c
  group Doc
    ../Doc/: readme.txt
