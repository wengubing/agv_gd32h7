# Keil uVision project project.uvprojx, settings and files
target Flash (6150000::V6.15::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H743xx
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User\libapp;..\..\User\bsp;..\..\User\fonts;..\..\User;..\..\RL-ARM\Driver;..\..\Libraries\CMSIS\Driver\Include;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\emWinDemo;..\..\emWin\JPEGConf;..\..\emWin\Config
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c includes.h
  group APP
    ../../User/libapp/: demo_sd_flashfs.c demo_dm9162_tcpnet.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_i2c_gpio.c bsp_fmc_sdram.c bsp_fmc_nand_flash.c bsp_i2c_eeprom_24xx.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_hcd.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_nand.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group RL-FlashFS/Driver
    ../../RL-ARM/Driver/: MCI_STM32H7xx.c
  group RL-TCPnet/Driver
    ../../RL-ARM/Driver/: ETH_INIT.c PHY_DM916x.c PHY_DM916x.h EMAC_STM32H7xx.c EMAC_STM32H7xx.h
  group RL-USB/Driver
    ../../RL-ARM/Driver/: OTG_STM32H7xx.c USBD_STM32H7xx.c USBH_HS1_STM32H7xx.c USBH_HS2_STM32H7xx.c
  group RL-USB/MassStorage
    ../../User/libapp/: MemoryDiskImage.c USBD_User_MSC_0.c USBD_User_MSC_1.c
  group RL-USB/HostStorage
    ../../User/libapp/: USBH_MSC.h USBH_MSC.c
  group GUI/Driver
    ../../User/bsp/src/: bsp_tft_h7.c bsp_tft_lcd.c bsp_ts_ft5x06.c bsp_ts_gt811.c bsp_ts_gt911.c bsp_ts_touch.c bsp_ts_stmpe811.c
  group GUI/GUI_OS
    ../../emWin/GUI_X/: GUI_X_RTE.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/Demo
    ../../emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/JPEG
    ../../emWin/JPEGConf/: decode_dma.c decode_dma.h JPEGConf.c JPEGConf.h
  group GUI/Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI/Lib
    ../../emWin/GUILib/: GUI_CM4F_L.lib
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Inc/: stm32h7xx_it.h
software components: CMSIS Driver:Ethernet MAC:Custom 1.0.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.13.8, File System:Drive:Memory Card 6.13.8, File System:Drive:NAND 6.13.8, File System:Drive:USB 6.13.8, Network:CORE 7.14.0, Network:Interface:ETH 7.14.0, Network:Service:FTP Server 7.14.0, Network:Socket:TCP 7.14.0, Network:Socket:UDP 7.14.0, USB:CORE 6.14.1, USB:Device 6.14.1, USB:Device:MSC 6.14.1, USB:Host 6.14.1, USB:Host:MSC 6.14.1, CMSIS Driver:Ethernet MAC 1.3.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.4.0, CMSIS Driver:NAND:Memory Bus 1.1.0, CMSIS Driver:USB Device 1.3.0, CMSIS Driver:USB Host 1.1.0, Device:STM32Cube HAL:Common 1.8.0, Device:STM32Cube HAL:Cortex 1.8.0, Device:STM32Cube HAL:DMA 1.8.0, Device:STM32Cube HAL:ETH 1.8.0, Device:STM32Cube HAL:GPIO 1.8.0, Device:STM32Cube HAL:HCD 1.8.0, Device:STM32Cube HAL:MMC 1.8.0, Device:STM32Cube HAL:PCD 1.8.0, Device:STM32Cube HAL:PWR 1.8.0, Device:STM32Cube HAL:RCC 1.8.0, Device:STM32Cube HAL:SD 1.8.0, Device:Startup 1.8.0
