# Keil uVision project project.uvproj, settings and files
target AgvChassisController (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output_masercar +hex
  c flags: Optim=1 wLevel=2
  c define: ACC_WXB,USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED=1
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Drivers\RTX\inc;..\..\Drivers\RTX\portable;..\..\Drivers\FatFS\src;..\..\Drivers\inc;..\..\Drivers\Common;..\..\Drivers\CanOpen\CanFestival-3\include;..\..\Drivers\CanOpen\CanFestival-3\include\STM32;..\..\Drivers\ModbusRtuPoll;..\..\Drivers\CustomUART;..\..\Drivers\CanOpen\CanFestival-3\example;..\..\SerialExp;..\..\User;..\..\User\AgvSimulator;..\..\HAL;..\..\HMI;..\..\ObjUpDate;..\..\ExternConfig;..\..\app_SkeletonAGV;..\..\ACC_Project;..\..\ACC_Project\ACC_Ctrl;..\..\ACC_Project\AgvChassisController;..\..\CBB;..\..\CBB\drivers\drv_ROKITData;..\..\CBB\drivers\drv_RFIDData;..\..\CBB\drivers\drv_MagneticNavigationData;..\..\CBB\drivers\drv_MergeToPGV;..\..\CBB\drivers\drv_KxdBMS;..\..\CBB\drivers\drv_PGVData;..\..\CBB\drivers\drv_BjfPGV;..\..\CBB\drivers\drv_ColorBand_PGV;..\..\CBB\user\basecalfunc;..\..\CBB\user\app_MotorResolving;..\..\CBB\user\app_DataFilter;..\..\CBB\user\app_FanCtrl;..\..\CBB\user\app_HMIScreenRefreshes;..\..\CBB\user\app_AlarmCode;..\..\CBB\user\app_Voiceplayer;..\..\CBB\user\app_LeadShineServoControl;..\..\CBB\user\app_ShelfAutadj;..\..\CBB\user\app_CenterPointCal;..\..\CBB\user\app_Assembly;..\..\CBB\user\app_PushRollerCtrl;..\..\CBB\user\app_DataSmoothing;..\..\CBB\user\app_MecanumWheel;..\..\CBB\user\app_DiscreteMagNav;..\..\CBB\user\app_SlamTrackLine;..\..\CBB\user\app_DoublePumpQuad_LiftCtrl;..\..\CBB\user\app_UnitePump_LiftCtrl;..\..\CBB\user\app_AGVAutoexcitationNode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c bsp.c AppTsk.c MB_LinkApp.c RTX_Conf_CM.c stm32f4xx_assert.c stm32f4xx_it.c includes.h CBB_Init.c EmgJudge.c ObjConf.c PowerOn.c Debug.c LinearCal.c CtrlSourceSwitch.c BaseApi.c Para_Sys.c Para_EEPROM.c Patch.c EQPComm_Init.c DateTime.c
    ../../Drivers/src/: drv_Servo.c
    ../../User/AgvSimulator/: AgvSimulator.c
  group ObjUpdate
    ../../ObjUpDate/: ObjUpdate.c ObjUpdate_ABS.c ObjUpdate_AGV.c ObjUpdate_BMS.c ObjUpdate_IO.c ObjUpdate_Lift.c ObjUpdate_LoadDetection.c ObjUpdate_Mag.c ObjUpdate_PGV.c ObjUpdate_RFID.c ObjUpdate_VoicePlayer.c ObjUpdate_WheelAngle.c ObjUpdate_Coord.c ObjUpdate_Assemly.c ObjUpdate_Color_Band.c ObjUpdate_VirtualMagnetic.c ObjUpdate_VirtualOdo.c ObjUpdate_API_Slave.c ObjUpdate_LeadShine.c
  group ExternConfig
    ../../ExternConfig/: Conf_Template.c Fun_Template.c Conf_Test.c Conf_User.c
  group ACC
    ../../ACC_Project/: ACC_Init.c ACC_Project.c
    ../../ACC_Project/ACC_Ctrl/: ACC_AbsorptionCtrl.c ACC_AGVCtrl.c ACC_AssemlyCtrl.c ACC_LegCtrl.c ACC_LiftCtrl.c ACC_WalkMotorResolving.c ACC_PushPullCtrl.c ACC_RollerCtrl.c ACC_AsbCtrl_OnlyRemote.c
  group AgvChassisController
    ../../ACC_Project/AgvChassisController/: AgvChassisController.c ACC_FaultsResponse.c ACC_LineTrace.c ACC_ModeSwitch.c ACC_OBS.c ACC_ServoEnCtrl.c ACC_AutoCentre.c ACC_AutoCruise.c ACC_CableRollCtrl.c ACC_LeadShineCtrl.c
  group HMI
    ../../HMI/: HMI.c HMI_ConfInit.c
  group CBB_AGV
    ../../app_SkeletonAGV/: app_SkeletonAGV.c app_DependenceAGV.c drv_path.c drv_pid.c app_AGVAutorunAccuratePosition.c app_AGVAutorunAltitude.c app_AGVAutorunBerthObstruct.c app_AGVAutorunHangHigh.c app_AGVAutorunLegTelescopic.c app_AGVAutorunWalk.c app_AGVAutorunPosture.c app_AGVAutorunSpecialCommand.c app_AGVInit.c app_AGVKalmanFilter.c
  group CBB
    ../../CBB/user/basecalfunc/: basecalfunc.c BoolFlashCtrl.c
    ../../CBB/user/app_MotorResolving/: app_MotorResolving.c
    ../../CBB/user/app_MagneticTrace/: app_MagneticTrace.c
    ../../CBB/user/app_MagneticVirtual/: app_MagneticVirtual.c
    ../../CBB/user/drv_VirtualOdometer/: drv_VirtualOdometer.c
    ../../CBB/user/app_SoundLightNotice/: app_SoundLightNotice.c
    ../../CBB/user/app_DataFilter/: app_DataFilter.c
    ../../CBB/user/app_DataSmoothing/: app_DataSmoothing.c
    ../../CBB/user/app_DiscreteMagNav/: app_DiscreteMagNav.c
    ../../CBB/user/app_IOFilter/: app_IOFilter.c
    ../../CBB/user/app_LiftCtrl/: app_LiftCtrl.c
    ../../CBB/user/app_LoadDetection/: app_LoadDetection.c
    ../../CBB/user/app_MagFilter/: app_MagFilter.c
    ../../CBB/user/app_MecanumWheel/: app_MecanumWheel.c
    ../../CBB/user/app_RadarObstacleAvoidance/: app_RadarObstacleAvoidance.c
    ../../CBB/user/app_ShelfAutadj/: app_ShelfAutadj.c
    ../../CBB/user/hal_HardwareInterfaceIO/: hal_HardwareInterfaceIO.c
    ../../CBB/drivers/drv_WirelessHandle/: drv_WirelessHandle.c
    ../../CBB/user/app_FanCtrl/: app_FanCtrl.c
    ../../CBB/user/app_HMIScreenRefreshes/: app_HMIScreenRefreshes.c
    ../../CBB/user/app_Voiceplayer/: app_Voiceplayer.c
    ../../CBB/user/app_CenterPointCal/: app_CenterPointCal.c
    ../../CBB/user/app_Assembly/: app_Assembly.c
    ../../CBB/drivers/drv_MergeToPGV/: drv_MergeToPGV.c
    ../../CBB/drivers/drv_KxdBMS/: drv_KxdBMS.c
    ../../CBB/drivers/drv_ROKITData/: drv_ROKITData.c
    ../../CBB/drivers/drv_RFIDData/: drv_RFIDData.c
    ../../CBB/drivers/drv_MagneticNavigationData/: drv_MagneticNavigationData.c
    ../../CBB/drivers/drv_BjfPGV/: drv_BjfPGV.c
    ../../CBB/drivers/drv_PGVData/: drv_PGVData.c
    ../../CBB/drivers/drv_BMSData/: drv_BMSData.c
    ../../CBB/user/app_PushPullCtrl/: app_PushPullCtrl.c
    ../../CBB/user/app_FixedJustify/: app_FixedJustify.c
    ../../CBB/drivers/drv_ColorBand_PGV/: drv_ColorBand_PGV.c
    ../../CBB/user/app_SlamTrackLine/: app_SlamTrackLine.c
    ../../CBB/user/app_DoublePumpQuad_LiftCtrl/: app_DoublePumpQuad_LiftCtrl.c
    ../../CBB/user/app_UnitePump_LiftCtrl/: app_UnitePump_LiftCtrl.c
    ../../CBB/user/app_AGVAutoexcitationNode/: app_AGVAutoexcitationNode.c
  group HAL
    ../../HAL/: IOConf.c ADDA.c CommConf.c
  group BSP
    ../../Drivers/src/: drv_ee_para.c drv_WatchDog.c drv_timer.c drv_sdio_sd.c drv_led.c drv_ADC.c drv_spi.c drv_analog.c drv_can.c drv_IO.c drv_Common.c drv_stm32f4rtc.c drv_1Wire.c drv_232Usart.c
  group SpiEEprom
    ../../Drivers/SPI_EEPROM/: spi_eeprom.c
  group SerialExp
    ../../SerialExp/: SerialExp_Disperse.h SwitchboardData.c
  group Custom_UART
    ../../Drivers/CustomUART/: Custom_UART.c
  group Modbus
    ../../Drivers/ModbusRtuPoll/: ModbusRtuPoll.c drv_485Usart.c
  group CanOpen
    ../../Drivers/CanOpen/CanFestival-3/example/: LinkCanopenMaster.c ObjectDictionary.c
    ../../Drivers/CanOpen/CanFestival-3/drivers/STM32/: canfestival_timer.c
  group CanFestival-3
    ../../Drivers/CanOpen/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c symbols.c
  group RTX/Source
    ../../Drivers/RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Ports
    ../../Drivers/RTX/portable/: HAL_CM4.c SVC_Table.s rt_HAL_CM.h
  group FatFS
    ../../Drivers/FatFS/src/: diskio.c ff.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_crc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_spdifrx.c stm32f4xx_wwdg.c
  group STM32F4xx_Dsp_Lib
    ../../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../../Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
